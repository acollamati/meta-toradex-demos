EXTRA_OECONF += "--disable-sdl"
