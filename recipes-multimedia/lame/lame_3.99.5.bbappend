FILESEXTRAPATHS_prepend := "${THISDIR}/lame:"
